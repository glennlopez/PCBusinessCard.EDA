File: PCBusinessCard/NFC_BusinessCard.kicad_sch (KiCad schematic)
At the start: 6 parts

Commit message: testing kicad 7 branch
